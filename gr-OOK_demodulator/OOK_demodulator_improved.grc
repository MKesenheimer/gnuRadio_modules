options:
  parameters:
    author: kesenheimer
    generate_options: hb
    id: OOK_demodulator_improved
    output_language: python
    run: 'False'
    title: Improved OOK demodulator
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.1'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.2'
    init: '0'
    low: '0.1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fbaud
  id: parameter
  parameters:
    type: eng_float
    value: 4800*4
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fbaud*2
    decim: int(samp_rate/re_samp_rate)
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_ccf
    width: fbaud
    win: firdes.WIN_HAMMING
  states: {}
- name: offset
  id: parameter
  parameters:
    label: offset
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sugout
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: bitout
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: spec
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: re_samp_rate
  id: parameter
  parameters:
    label: Target sample rate
    value: '96000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.4e6
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', pad_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
