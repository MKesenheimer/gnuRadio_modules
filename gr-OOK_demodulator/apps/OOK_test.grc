options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: OOK_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: data
  id: variable
  parameters:
    value: (1,1,1,1,1,1,1,1,1,0, 1, 0,1,1,0,0,1,0)
  states: {}
- name: freq_0
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: OOKDemodulator_1
  id: OOKDemodulator
  parameters:
    freq_0: freq_0
    gain: '2'
    low_pass_cutoff: '5000'
    offset: '0.5'
    samp_per_sym: '600'
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_modules/OOK_test/OOK_test.bin
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '600'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: data
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [OOKDemodulator_1, '0', blocks_file_sink_0, '0']
- [OOKDemodulator_1, '1', qtgui_sink_x_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', OOKDemodulator_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_repeat_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
