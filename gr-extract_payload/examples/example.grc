options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {}
- name: extract_payload_1
  id: extract_payload
  parameters:
    bitpattern: (0, 0, 0)
    headerLength: '32'
    payloadLength: '32'
  states: {}

connections:
- [blocks_throttle2_0, '0', extract_payload_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [extract_payload_1, '0', blocks_null_sink_0, '0']
- [extract_payload_1, '0', blocks_vector_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
