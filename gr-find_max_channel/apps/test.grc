options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '10'
    min: '0'
    num_samps: '300'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_modules/gr-find_max_channel/apps/stdout
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: float
    vec_rate: samp_rate / 10
    vlen: '10'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: find_max_channel_0
  id: find_max_channel
  parameters:
    vector_length: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: '30'
    srate: samp_rate / 10
    type: float
    update_time: '1'
    ymax: '10'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '300'
    srate: samp_rate
    type: float
    update_time: '1'
    ymax: '10'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [blocks_int_to_float_0, '0', blocks_stream_to_vector_decimator_0, '0']
- [blocks_int_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_decimator_0, '0', find_max_channel_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [find_max_channel_0, '0', blocks_file_sink_0, '0']
- [find_max_channel_0, '0', qtgui_time_sink_x_0, '0']
- [find_max_channel_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_1, '1']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
