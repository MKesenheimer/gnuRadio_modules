options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '0'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: (0, 0, 0)
  states: {}
- name: synced_manchester_decode_0
  id: synced_manchester_decode
  parameters:
    bit_mode: '0'
    endianess: '0'
    nsync_symbols: '0'
    samples_per_symbol: '4'
  states: {}

connections:
- [blocks_throttle2_0, '0', synced_manchester_decode_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [synced_manchester_decode_0, '0', blocks_vector_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
